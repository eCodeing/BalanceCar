# Keil uVision project My_Project.uvprojx, settings and files
target My_Project (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: My_Project +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\CORE;..\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\WZY\LED;..\WZY\BEEP;..\WZY\KEY;..\WZY\EXTI;..\WZY\OLED;..\WZY\SPI1;..\WZY\UART3;..\WZY\IOIIC;..\WZY\MPU6050;..\WZY\TB6612;..\WZY\TIMER;..\DMP;..\WZY\BATVAL;..\WZY\ENCODER;..\WZY\CONTROL;..\WZY\NRF24L01;..\WZY\SPI;..\WZY\FRAME;..\WZY\GLOBAL;..\APP;..\WZY\PROTOCOL;..\WZY\STMFLASH;..\WZY\FILTER;..\WZY\MATHS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group APP
    ../APP/: task.c
  group BSP
    ../BSP/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group WZY
    ../WZY/LED/: led.c
    ../WZY/KEY/: key.c
    ../WZY/EXTI/: exti.c
    ../WZY/OLED/: oled.c
    ../WZY/UART3/: uart3.c
    ../WZY/IOIIC/: ioiic.c
    ../WZY/MPU6050/: mpu6050.c
    ../WZY/TB6612/: tb6612.c
    ../WZY/TIMER/: timer.c
    ../WZY/BATVAL/: batval.c
    ../WZY/ENCODER/: encoder.c
    ../WZY/CONTROL/: control.c
    ../WZY/FRAME/: frame.c
    ../WZY/GLOBAL/: global.c
    ../WZY/PROTOCOL/: protocol.c
    ../WZY/NRF24L01/: SPI_NRF24L01.c
    ../WZY/STMFLASH/: stmflash.c
    ../WZY/FILTER/: filter.c
    ../WZY/MATHS/: maths.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group DMP
    ../DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
